#include "apps/maze-break/gfx/font.hpp"

namespace maze_break::gfx {
namespace {

// Each glyph is 7 rows of 5 bits, MSB first.
struct Glyph {
    char symbol;
    uint8_t rows[kGlyphHeight];
};

constexpr Glyph kGlyphs[] = {
    {'0', {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E}}, {'1', {0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E}},
    {'2', {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F}}, {'3', {0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E}},
    {'4', {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02}}, {'5', {0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E}},
    {'6', {0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E}}, {'7', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}},
    {'8', {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E}}, {'9', {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C}},
    {'A', {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}}, {'B', {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E}},
    {'C', {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E}}, {'D', {0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C}},
    {'E', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F}}, {'F', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10}},
    {'G', {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F}}, {'H', {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'I', {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E}}, {'J', {0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C}},
    {'K', {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}}, {'L', {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F}},
    {'M', {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11}}, {'N', {0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11}},
    {'O', {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}}, {'P', {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10}},
    {'Q', {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D}}, {'R', {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11}},
    {'S', {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E}}, {'T', {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
    {'U', {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}}, {'V', {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04}},
    {'W', {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A}}, {'X', {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11}},
    {'Y', {0x11, 0x11, 0x11, 0x0A, 0x04, 0x04, 0x04}}, {'Z', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}},
    {'.', {0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C}}, {':', {0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00}},
    {'/', {0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10}}, {'-', {0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00}},
    {'%', {0x18, 0x19, 0x02, 0x04, 0x08, 0x13, 0x03}}, {'!', {0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04}},
    {'+', {0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00}},
};

int Length(const char* text) {
    int length = 0;
    while (text[length] != '\0') {
        ++length;
    }
    return length;
}

int FindIndex(char symbol) {
    if (symbol >= 'a' && symbol <= 'z') {
        symbol = static_cast<char>(symbol - 'a' + 'A');
    }
    constexpr int kCount = static_cast<int>(sizeof(kGlyphs) / sizeof(kGlyphs[0]));
    for (int index = 0; index < kCount; ++index) {
        if (kGlyphs[index].symbol == symbol) {
            return index;
        }
    }
    return -1;
}

constexpr int kCellsPerRow = kGlyphAtlasWidth / kGlyphCell;
static_assert(sizeof(kGlyphs) / sizeof(kGlyphs[0]) <= kCellsPerRow * (kGlyphAtlasHeight / kGlyphCell),
              "glyph atlas too small");

}  // namespace

int TextWidth(const char* text, int scale) {
    const int length = Length(text);
    return length == 0 ? 0 : (length * (kGlyphWidth + 1) - 1) * scale;
}

void BuildGlyphAtlas(uint8_t* atlas) {
    for (int index = 0; index < kGlyphAtlasBytes; ++index) {
        atlas[index] = 0U;
    }
    constexpr int kCount = static_cast<int>(sizeof(kGlyphs) / sizeof(kGlyphs[0]));
    for (int index = 0; index < kCount; ++index) {
        const int u0 = (index % kCellsPerRow) * kGlyphCell;
        const int v0 = (index / kCellsPerRow) * kGlyphCell;
        for (int row = 0; row < kGlyphHeight; ++row) {
            const uint8_t bits = kGlyphs[index].rows[row];
            for (int column = 0; column < kGlyphWidth; ++column) {
                if ((bits & (0x10 >> column)) != 0) {
                    atlas[(u0 + column) * kGlyphAtlasHeight + v0 + row] = 1U;
                }
            }
        }
    }
}

bool GlyphCell(char symbol, int& u0, int& v0) {
    const int index = FindIndex(symbol);
    if (index < 0) {
        return false;
    }
    u0 = (index % kCellsPerRow) * kGlyphCell;
    v0 = (index / kCellsPerRow) * kGlyphCell;
    return true;
}

}  // namespace maze_break::gfx
